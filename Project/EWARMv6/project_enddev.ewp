# IAR project project_enddev.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\uCOS-II\uCOS-II\Source; ..\..\uCOS-II\uC-LIB; ..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\..\uCOS-II\uC-CPU\ARM-Cortex-M3\IAR; ..\..\uCOS-II\uC-CPU; ..\..\User; ..\..\User\radio\sx127x\inc; ..\..\User\key\src; ..\..\User\lcd\src; ..\..\User\ds18b20\src; ..\..\User\sys\src; ..\..\User\up\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_enddev.srec
  ILINK.IlinkOutputFile: project_enddev.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../../User/bsp/: bsp.c stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_cpu_flash.c bsp_led.c bsp_spi_bus.c bsp_timer.c bsp_user_lib.c bsp_wwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
  group PKT/ds18b20
    ../../User/ds18b20/src/: ds18b20.c
  group PKT/key
    ../../User/key/src/: key.c
  group PKT/lcd
    ../../User/lcd/src/: lcd.c
  group PKT/math/crc
    ../../User/math/crc/src/: crc16.c
  group PKT/radio/sx127x
    ../../User/radio/sx127x/src/: sx127x_driv.c sx127x_protocol.c
  group PKT/up
    ../../User/up/src/: up.c
  group STD_DRIV
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group USER
    ../../User/: app.c app_cfg.h app_hooks.c cpu_bsp.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
